# Keil uVision project calendar.uvprojx, settings and files
target calendar (5060960::V5.06 update 7 (build 960)::.\ARMCC5.06)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.7
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: calendar +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\at32f403a_407_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c rtc.c
  group bsp
    ../../../../../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f403a_407_gpio.c at32f403a_407_crm.c at32f403a_407_pwc.c at32f403a_407_usart.c at32f403a_407_misc.c at32f403a_407_rtc.c at32f403a_407_bpr.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group readme
    ../: readme.txt
